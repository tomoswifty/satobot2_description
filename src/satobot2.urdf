Commit message: fix lidar position

File: src/satobot2.urdf (robot description, URDF)
Before this commit: robot msd700_mk4, 5 links, 4 joints
Joints:
- joint livox_lidar_joint: origin xyz=-0.119 0.0 0.390 rpy=0 0 0 -> xyz=-0.119 0.0 0.415 rpy=0 0 0
